# Keil uVision project MTI.uvprojx, settings and files
target Robocon_KIZUNA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MTI +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,__FPU_USED=1
  c misc: --c99
  c include: ..\MTI_USER;..\CORE;..\FWLB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Robocon_F427;..\MTI_USER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./: main.c system_stm32f4xx.c
  group MTI_USER
    ../MTI_USER/: gpio.c nvic.c can.c timer.c uart.c dma.c stm32f4xx_it.c iwdg.c remote.c hi219m.c imu_data_decode.c packet.c M3508.c pid.c user_task.c
    ./: PointRabbit.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group FWLIB
    ../FWLB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CORE
    ../CORE/: startup_stm32f427xx.s core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group TOur
    ./: ChassisCtrl.c
